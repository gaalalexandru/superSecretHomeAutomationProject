# Keil uVision project HomeAutomationSlave.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HomeAutomationSlave
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: ..\..\..\TivaWare_C_Series-2.1.1.71\driverlib\rvmdk;..\..\..\TivaWare_C_Series-2.1.1.71;.\drivers\adc_handler;.\drivers\gpio_handler;.\drivers\i2c_handler;.\drivers\timer_handler;.\application\cyclic_container;.\application\startup_container;..\HomeAutomationSlave;.\drivers\pwm_handler;.\drivers\spi_handler;.\application\lighting
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ./application/cyclic_container/: cyclic_container.c
    ./application/startup_container/: startup_container.c
    ./application/lighting/: light_app.c
    ./: heat_app.c heat_app.h
  group drivers
    ./drivers/gpio_handler/: gpio_handler.c
    ./drivers/adc_handler/: adc_handler.c
    ./drivers/timer_handler/: timer_handler.c
    ./drivers/i2c_handler/: i2c_handler.c
    ./drivers/pwm_handler/: pwm_handler.c
    ./drivers/spi_handler/: spi_handler.c
  group main
    ./: main.c custom_types.h
  group driverlib
    ../../../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
  group display
    ./: display.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.1
